options:
  parameters:
    author: admin
    generate_options: no_gui
    id: tup_rdo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-tx_rx_mix_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tx_rx_mix_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:3,0
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:3,0
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: tx_rx_mix_freq + (tx_rx_bw /2) + 1000
    low_cutoff_freq: tx_rx_mix_freq - (tx_rx_bw /2) - 1000
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern(f"{message_str}")
    period: '500'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mult_amp
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: wav_file_path
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: tx_rx_bw
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,True]'
    samp_rate: samp_rate
    sf: tx_rx_sf
    soft_decoding: 'True'
    sync_word: tx_rx_sync_word
  states: {}
- name: lora_sdr_payload_id_inc_0
  id: lora_sdr_payload_id_inc
  parameters:
    separator: ':'
  states: {state: disabled}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: tx_rx_bw
    cr: tx_cr
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: samp_rate
    sf: tx_rx_sf
    sync_word: tx_rx_sync_word
  states: {}
- name: message_str
  id: parameter
  parameters:
    type: str
    value: TEST
  states: {}
- name: mult_amp
  id: parameter
  parameters:
    type: eng_float
    value: '0.5'
  states: {}
- name: tx_cr
  id: parameter
  parameters:
    type: intx
    value: '1'
  states: {}
- name: tx_rx_bw
  id: parameter
  parameters:
    type: intx
    value: '8000'
  states: {}
- name: tx_rx_mix_freq
  id: parameter
  parameters:
    type: intx
    value: '1000'
  states: {}
- name: tx_rx_sf
  id: parameter
  parameters:
    type: intx
    value: '7'
  states: {}
- name: tx_rx_sync_word
  id: parameter
  parameters:
    value: '[0x12]'
  states: {}
- name: wav_file_path
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [band_pass_filter_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_message_strobe_0, strobe, lora_sdr_payload_id_inc_0, msg_in]
- [blocks_message_strobe_0, strobe, lora_tx_0, in]
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_multiply_xx_0, '0', lora_rx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [lora_sdr_payload_id_inc_0, msg_out, blocks_message_strobe_0, set_msg]
- [lora_tx_0, '0', blocks_multiply_xx_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
